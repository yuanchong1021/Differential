# IAR project Differentialyct.ewp, settings and files
configuration FLASH (ARM)
  General.OGChipSelectEditMenu: YTM32B1LE14 YTM32B1LE14
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: YTM32B1LE1; CPU_YTM32B1LE1
  ICCARM.CCIncludePath2: ../board; ../platform/drivers/src/clock/YTM32B1Lx; ../platform/drivers/src/pins; ../platform/drivers/src/dma; ../platform/drivers/src/lptmr; ../platform/drivers/src/mpwm; ../platform/drivers/src/adc; ../platform/drivers/inc; ../platform/devices/common; ../platform/devices; ../platform/devices/YTM32B1LE1/include; ../platform/devices/YTM32B1LE1/startup; ../CMSIS/Core/Include; ../rtos/osif; ..\app; ..\bsp; ..\task
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../board; ../platform/drivers/src/clock/YTM32B1Lx; ../platform/drivers/src/pins; ../platform/drivers/src/dma; ../platform/drivers/src/lptmr; ../platform/drivers/src/mpwm; ../platform/drivers/src/adc; ../platform/drivers/inc; ../platform/devices/common; ../platform/devices; ../platform/devices/YTM32B1LE1/include; ../platform/devices/YTM32B1LE1/startup; ../CMSIS/Core/Include; ../rtos/osif
  OBJCOPY.OOCOutputFile: Differentialyct.hex
  ILINK.IlinkOutputFile: Differentialyct.out
  ILINK.IlinkIcfFile: ../board/yt_linker.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group app
    ../app/: app_tc.c app_tc.h main.c
  group board
    ../board/: clock_config.c clock_config.h pin_mux.c pin_mux.h yt_linker.icf RamInit0.S RamInit1.c RamInit2.c startup.S vector.S vector_table_copy.c interrupt_config.c interrupt_config.h lptmr_config.c lptmr_config.h mpwm_config.c mpwm_config.h sdk_project_config.h
  group bsp
    ../bsp/: bsp_indicator.c bsp_indicator.h bsp_motor.c bsp_motor.h bsp_position_gpio.c bsp_position_gpio.h bsp_switch.c bsp_switch.h
  group CMSIS/Core/Include
    ../CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_ccarm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
  group platform/drivers/src/clock/YTM32B1Lx
    ../platform/drivers/src/clock/YTM32B1Lx/: cfmu_hw_access.h clock_YTM32B1Lx.c clock_YTM32B1Lx.h cmu_hw_access.h ipc_hw_access.h scu_hw_access.h
  group platform/drivers/src/clock/YTM32B1Lx/doxygen
    ../platform/drivers/src/clock/YTM32B1Lx/doxygen/: clock_YTM32B1Lx.dox
  group platform/drivers/src/pins
    ../platform/drivers/src/pins/: pins_driver.c pins_gpio_hw_access.h pins_port_hw_access.c pins_port_hw_access.h
  group platform/drivers/src/pins/doxygen
    ../platform/drivers/src/pins/doxygen/: pins.dox
  group platform/drivers/src/interrupt
    ../platform/drivers/src/interrupt/: interrupt_manager.c
  group platform/drivers/src/interrupt/doxygen
    ../platform/drivers/src/interrupt/doxygen/: interrupt.dox
  group platform/drivers/src/lptmr
    ../platform/drivers/src/lptmr/: lptmr_driver.c lptmr_hw_access.c lptmr_hw_access.h
  group platform/drivers/src/lptmr/doxygen
    ../platform/drivers/src/lptmr/doxygen/: lptmr.dox lptmr_driver.dox
  group platform/drivers/src/mpwm
    ../platform/drivers/src/mpwm/: mpwm_common.c mpwm_hw_access.h mpwm_pwm_driver.c
  group platform/drivers/inc
    ../platform/drivers/inc/: clock.h clock_manager.h pins_driver.h interrupt_manager.h lptmr_driver.h mpwm_common.h mpwm_pwm_driver.h
  group platform/devices
    ../platform/devices/: callbacks.h devassert.h device_registers.h floats.h status.h
  group platform/devices/common
    ../platform/devices/common/: core_common.h
  group platform/devices/YTM32B1LE1/include
    ../platform/devices/YTM32B1LE1/include/: YTM32B1LE1.h YTM32B1LE1_features.h
  group platform/devices/YTM32B1LE1/startup
    ../platform/devices/YTM32B1LE1/startup/: system_YTM32B1LE1.c system_YTM32B1LE1.h
  group rtos/osif
    ../rtos/osif/: osif.h osif_baremetal.c
  group task
    ../task/: task_ctrl.c task_ctrl.h task_position.c task_position.h task_sched.c task_sched.h task_switch.c task_switch.h
